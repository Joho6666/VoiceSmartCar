# Keil uVision project VoiceSmartCar.uvproj, settings and files
target DryRun_12T (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200)
  output: VoiceSmartCar +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: VOICECAR_12T=1
  c include: .;.\firmware;C:\Keil_v5\C51\INC
  group 
    ./firmware/: main.c bsp_timer.c bsp_uart.c bsp_motor.c car_core.c action_sequence.c motion_controller.c safety.c voice_protocol.c
target DryRun_6T (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200)
  output: VoiceSmartCar +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: VOICECAR_6T=1
  c include: .;.\firmware;C:\Keil_v5\C51\INC
target Hardware (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(11059200)
  output: VoiceSmartCar +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: VOICECAR_HARDWARE=1;VOICECAR_12T=1
  c include: .;.\firmware;C:\Keil_v5\C51\INC
